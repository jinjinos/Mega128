# IAR project atmega128.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0xff
  General.SCCStackSize: 0xff
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128a ATmega128A
  ICCAVR.newCCIncludePaths: inc
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128a.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  group INC
    inc/: adc.h beep.h dac_tlc5615.h delay.h ds1302.h ds18b20.h e2prom.h ISR.h key.h lcd1602.h led.h ledshow.h my_math.h queue.h redctrl.h regBit.h removectrl.h spi.h step_motor.h timer.h uart.h
    src/: song.h
  group SRC
    src/: adc.c beep.c dac_tlc5615.c delay.c ds1302.c ds18b20.c e2prom.c ISR.c key.c lcd1602.c led.c ledshow.c main.c my_math.c queue.c redctrl.c removectrl.c song.c spi.c step_motor.c timer.c uart.c
